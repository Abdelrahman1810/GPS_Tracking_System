# Keil uVision project First Milestone.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: First Milestone
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s system_TM4C123.c
    ../CODES/: DIO_program.c main.c BIT_MATH.h DIO_interface.h DIO_private.h STD_TYPES.h tm4c123gh6pm.h
